# Keil uVision project seekfree.uvproj, settings and files
target stc32g144k246 (MCS-251)
  device: STC32G144K246 Series STC
  cpu: IRAM(0-0x3FFF) XRAM(0x10000-0x2FFFF) IROM(0xFC2800-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  asm include: ..\..\libraries\zf_common
  link misc: REMOVEUNUSED,NOOVERLAY
  group doc
    ../../libraries/doc/: version.txt
  group zf_common
    ../../libraries/zf_common/: stc32g144k246.h START251.A51 zf_common_headfile.h zf_common_typedef.c zf_common_typedef.h zf_common_clock.c zf_common_clock.h zf_common_interrupt.c zf_common_interrupt.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_eeprom.c zf_driver_eeprom.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_usb_cdc.c zf_driver_usb_cdc.h
  group zf_device
    ../../libraries/zf_device/: zf_device_type.c zf_device_type.h zf_device_config.LIB zf_device_config.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_mt9v03x_dma.LIB zf_device_mt9v03x_dma.h zf_device_ips114.h zf_device_tft180.h zf_device_ips200.c zf_device_ips200.h zf_device_ips200pro.h zf_device_ble6a20.h zf_device_wifi_spi.h zf_device_wireless_uart.h
  group zf_components
    ../../libraries/zf_components/stc32g_usb_lib/: config.h stc.h usb.c usb.h usb_desc.c usb_desc.h usb_req_class.c usb_req_class.h usb_req_std.c usb_req_std.h usb_req_vendor.c usb_req_vendor.h util.c util.h
    ../../libraries/zf_components/seekfree_assistant/: seekfree_assistant.h seekfree_assistant_interface.h
  group code
    ../code/: Image.c Image.h Track.c BendEntry.c BendEntry.h Motor.c Motor.h Stop.c Stop.h SCurve.c SCurve.h Round.c Round.h XCross.c XCross.h
  group user
    ../user/: isr.c isr.h isr_extended_0.c isr_extended_1.c isr_extended_vectors.A51 main.c
